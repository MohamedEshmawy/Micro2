# Keil uVision project part2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: part2
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s main.c
    ./drivers/: IC_L293D.c StepperMotor.c
    ./MCAL/: ADC.c MCAL_DIO.c PWM.c UART22.c ONEUART.c MCAL_UART5.c
    ./extra/: qeue.c
